Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 36c567f4-5c29-45cb-b3b1-0b328a6e1241, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T23:27:30+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 09850160_GB_KWT6321UG:36632100_GB_9850160_KWT6321UG, (2)
In: Default
Type - Material: Spruce, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel_Black, z_Miele_Design_Glass, z_Miele_Connection_Electric, Polypropylene, z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 819 mm; Depth: 575 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36632100_GB_9850160_KWT6321UG; sets with these values: 2
